options:
  parameters:
    generate_options: qt_gui
    id: TransmisorQAM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud Portadora
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.250'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud Mensaje
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.250'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: '500000000'
  states: {}
- name: Fm1
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Mensaje 1
    start: '0'
    step: '100'
    stop: '1000000'
    value: '1000'
  states: {}
- name: Fm2
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Mensaje 2
    start: '0'
    step: '100'
    stop: '1000000'
    value: '1000'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia TX
    start: '0'
    step: '1'
    stop: '31'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: ArizaValestEnvolventeComplejaDSBSC_0
  id: ArizaValestEnvolventeComplejaDSBSC
  parameters:
    Ac: Ac
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: Fm1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: Fm2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ArizaValestEnvolventeComplejaDSBSC_0, '0', qtgui_freq_sink_x_0, '0']
- [ArizaValestEnvolventeComplejaDSBSC_0, '0', qtgui_time_sink_x_0, '0']
- [ArizaValestEnvolventeComplejaDSBSC_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', ArizaValestEnvolventeComplejaDSBSC_0, '0']
- [analog_sig_source_x_1, '0', ArizaValestEnvolventeComplejaDSBSC_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
