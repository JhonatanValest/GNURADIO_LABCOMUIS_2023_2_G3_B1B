options:
  parameters:
    author: ArizaValestG3
    copyright: Uis
    generate_options: qt_gui
    id: Modulador_de_amplitud
    output_language: python
    title: Modulador de amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud de la Portadora (Ac)
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.125'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: Cambio de Banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del Transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: Habilita Portadora
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: '50000000'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de mensaje
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1562500'
  states: {}
- name: ArizaValestModuladorSSB_0
  id: ArizaValestModuladorSSB
  parameters:
    Ac: Ac
    B: B
    k: K
  states: {}
- name: CalculoPotenciaComunicaciones_0
  id: CalculoPotenciaComunicaciones
  parameters:
    I_vect: '1024'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [ArizaValestModuladorSSB_0, '0', qtgui_freq_sink_x_0, '0']
- [ArizaValestModuladorSSB_0, '0', qtgui_time_sink_x_0, '0']
- [ArizaValestModuladorSSB_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', ArizaValestModuladorSSB_0, '0']
- [analog_sig_source_x_0, '0', CalculoPotenciaComunicaciones_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
